# Keil uVision project matrixKeyboard.uvprojx, settings and files
target mainFrame (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: matrixKeyboard
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group enterPoint
    ./: main.c
  group timeControl
    ./: timeControl.c timeControl.h
  group initModule
    ./: initModule.c initModule.h
  group buttonControl
    ./: buttonControl.c buttonControl.h
software components: CMSIS:CORE 5.0.1, Device:Startup 2.2.3
